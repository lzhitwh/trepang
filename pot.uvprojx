# Keil uVision project pot.uvprojx, settings and files
target pot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\APP;.\BSP;.\BSP\usart;.\CMSIS;.\content;.\function;.\FWlib\inc;.\FWlib\src;.\item;.\PeriphMode\DM13A;.\PeriphMode\ds18b20;.\PeriphMode\esp8266;.\PeriphMode\key;.\PeriphMode\lcd;.\PeriphMode\lcd\screen;.\PeriphMode\lcd\ziku;.\UCOS-II\PORTS;.\UCOS-II\SOURSE;.\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group Ucos-II/Ports
    ./UCOS-II/PORTS/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group Ucos-II/Source
    ./UCOS-II/SOURSE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ./BSP/: bsp.c
    ./BSP/usart/: usart1.c usart2.c
  group PeriphMode
    ./PeriphMode/DM13A/: dm13a.c
    ./PeriphMode/ds18b20/: ds18b20.c
    ./PeriphMode/esp8266/: esp8266.c
    ./PeriphMode/key/: key.c keyrun.c
    ./PeriphMode/lcd/: lcd.c
    ./PeriphMode/lcd/ziku/: ziku.c
    ./PeriphMode/lcd/screen/: screen.c
  group User
    ./user/: main.c stm32f10x_it.c
  group App
    ./APP/: app.c
  group Function
    ./function/: function.c functionother.c updatetime.c
  group Display
    ./content/: cdisplay.c
    ./item/: 0zero.c 1one.c 2two.c 3three.c 4four.c 5five.c 6six.c 7seven.c 8eight.c 9nine.c 10ten.c 11eleven.c 12twelve.c 13thirteen.c 14fourteen.c 15fifteen.c 16sixteen.c
