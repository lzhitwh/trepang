# Keil uVision project STM32-DEMO.uvprojx, settings and files
target STM32-DEMO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\user;..\APP;..\BSP;..\UCOS-II\PORTS;..\UCOS-II\SOURSE;..\BSP\usart;..\BSP\led;..\BSP\esp8266;..\lcd\screen;..\lcd\ziku;..\lcd;..\BSP\ds18b20;..\BSP\key;..\function;..\content;..\item;..\BSP\DM13A
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group UCOS-II/sourse
    ../UCOS-II/SOURSE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-II/ports
    ../UCOS-II/PORTS/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group BSP
    ../BSP/: bsp.c
  group App
    ../APP/: app.c
  group usart
    ../BSP/usart/: usart1.c usart2.c
  group dm13a
    ../BSP/DM13A/: dm13a.c
  group esp8266
    ../BSP/esp8266/: esp8266.c
  group lcd
    ../lcd/: lcd.c
    ../lcd/screen/: screen.c
    ../lcd/ziku/: ziku.c
  group ds18b20
    ../BSP/ds18b20/: ds18b20.c
  group key
    ../BSP/key/: key.c keyrun.c
  group function
    ../function/: function.c updatetime.c functionother.c
  group lcddisplay
    ../content/: cdisplay.c
  group item
    ../item/: 0zero.c 1one.c 2two.c 3three.c 4four.c 5five.c 6six.c 7seven.c 8eight.c 9nine.c 10ten.c 11eleven.c 12twelve.c 13thirteen.c 14fourteen.c 15fifteen.c 16sixteen.c
software components: CMSIS:CORE 5.0.1
